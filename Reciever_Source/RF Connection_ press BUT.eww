<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RF Connection_ press BUT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


