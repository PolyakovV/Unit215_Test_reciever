# IAR project RF Connection_ press BUT.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.PreInclude: C:\Users\Valentine\Desktop\Reciver Texas Instr Datasheet\My_test\usart.h
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    HAL/: cc430x613x_PMM.c cc430x613x_PMM.h HAL_FLASH.c HAL_FLASH.h RF1A.c RF1A.h
    ./: main.c usart.c usart.h Valik_os.c Valik_os.h
